# Keil uVision project can_controlled_automotive_info_display.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LPC2129 NXP
  cpu: IRAM(0x40000000-0x40003FFF) IROM(0-0x3FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: main_node +hex
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x40000000 size 0x4000
  group Source Group 1
    ./: ADC.c ds18b20.c RTC.c lcd.c LED_indicator.c Startup.s tdelay.c EXTINT_Interrupt.c CAN.c
  group Main Node
    ./MAIN_NODE/: main_node_utils.c main_node.c
  group Indicator Node
    ./INDICATOR_NODE/: indicator_node.c
  group Fuel Node
    ./FUEL NODE/: fuel_node_utils.c fuel_node.c
  group tests
    ./tests/: ds18b20_test.c display_fuel_indicator_test.c can_rx_fuel.c can_text_rx.c CAN_test_tx.c
